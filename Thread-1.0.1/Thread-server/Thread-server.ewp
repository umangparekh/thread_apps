# IAR project Thread-server.ewp, settings and files
configuration Normal (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: APP_BTL; CORTEXM3; CORTEXM3_EMBER_MICRO; CORTEXM3_EM3588; PHY_EM3XX; BOARD_HEADER="thread-board.h"; CONFIGURATION_HEADER="thread-configuration.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; __SOURCEFILE__="$FILE_FNAME$"; BOARD_DEV0680ETM; EMBER_AF_API_EMBER_TYPES="stack/include/ember-types.h"; EMBER_STACK_IP; EMBER_RIP_STACK; HAVE_TLS_JPAKE; DEBUG_LEVEL=FULL_DEBUG; APPLICATION_TOKEN_HEADER="thread-token.h"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros; --separate_cluster_for_initialized_variables
  ICCARM.CCIncludePath2: $FILE_DIR$; $PROJ_DIR$; ..; ..\app\util; ..\stack; ..\hal; ..\hal\..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: APP_BTL; CORTEXM3; CORTEXM3_EMBER_MICRO; CORTEXM3_EM3588; PHY_EM3XX; BOARD_HEADER="thread-board.h"; CONFIGURATION_HEADER="thread-configuration.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; BOARD_DEV0680ETM; EMBER_AF_API_EMBER_TYPES="stack/include/ember-types.h"; EMBER_STACK_IP; EMBER_RIP_STACK; HAVE_TLS_JPAKE; DEBUG_LEVEL=FULL_DEBUG; APPLICATION_TOKEN_HEADER="thread-token.h"
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: Thread-server.s37
  prebuild: Thread-server-prebuild.bat $PROJ_DIR$
  postbuild: Thread-server-postbuild.bat $TARGET_BPATH$
  ILINK.IlinkOutputFile: Thread-server.out
  ILINK.IlinkConfigDefines: APP_BTL=1
  ILINK.IlinkIcfFile: ..\hal\micro\cortexm3\em35x\em3588\iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: halEntryPoint
  group (top)
    ../build/hal-library-cortexm3-iar-em3588-em3xx/: hal-library.a
    ../build/mfglib-library-cortexm3-iar-em3588-em3xx/: mfglib-library.a
    ../build/sim-eeprom1-library-cortexm3-iar-em3588-em3xx/: sim-eeprom1-library.a
    ../build/thread-stack-cortexm3-iar-em3588-em3xx/: thread-stack.a
  group adc
    ../hal/micro/cortexm3/: adc.c
  group address-configuration-debug
    ../app/thread/plugin/address-configuration-debug/: address-configuration-debug.c
  group button
    ../hal/micro/cortexm3/: button.c
  group buzzer
    ../hal/micro/cortexm3/: buzzer.c
  group cli
    ../app/thread/plugin/cli/: cli.c
  group coap-cli
    ../app/thread/plugin/coap-cli/: coap-cli.c
  group command-interpreter2
    ../app/util/serial/: command-interpreter2-error.c command-interpreter2-util.c command-interpreter2.c
  group debug-print
    ../app/thread/plugin/debug-print/: debug-print.c
  group dhcp-client
    ../app/thread/plugin/dhcp-client/: dhcp-client.c
  group diagnostic
    ../hal/micro/cortexm3/: diagnostic.c
  group global-address-prefix-debug
    ../app/thread/plugin/global-address-prefix-debug/: global-address-prefix-debug.c
  group hal-library
    ../hal/micro/cortexm3/: assert-crash-handlers.c cstartup-common.c faults.s79 isr-stubs.s79 mfg-token.c micro-common.c micro.c mpu.c sleep.c token-def.c token.c uart.c
    ../hal/micro/cortexm3/usb/cdc/: callbacks.c
    ../hal/micro/cortexm3/usb/: em_usbd.c em_usbdch9.c em_usbdep.c em_usbhal.c em_usbint.c em_usbtimer.c
    ../hal/micro/generic/: crc.c endian.c mem-util.c random.c
  group heartbeat
    ../app/thread/plugin/heartbeat/: heartbeat.c
  group icmp-cli
    ../app/thread/plugin/icmp-cli/: icmp-cli.c
  group icmp-debug
    ../app/thread/plugin/icmp-debug/: icmp-debug.c
  group idle-sleep
    ../app/thread/plugin/idle-sleep/: idle-sleep.c
  group led
    ../hal/micro/cortexm3/: led.c
  group main
    ../app/thread/plugin/main/: main.c
  group network-management-cli
    ../app/thread/plugin/network-management-cli/: network-management-cli.c
  group scan-debug
    ../app/thread/plugin/scan-debug/: scan-debug.c
  group serial
    ../app/util/serial/: serial-printf.c serial.c
  group sim-eeprom1
    ../hal/micro/generic/: sim-eeprom.c
  group slaac-client
    ../app/thread/plugin/slaac-client/: slaac-client.c
  group tftp-bootload-target
    ../app/util/bootload/tftp-bootloader/server/: tftp-bootloader-server.c
    ../app/util/bootload/tftp-bootloader/: tftp-bootloader-15-4.c tftp-bootloader.c
    ../app/util/bootload/tftp/server/: tftp-server.c
    ../app/util/bootload/tftp/: tftp-15-4.c tftp.c
    ../app/thread/plugin/tftp-bootload-target/: tftp-bootload.c
  group thread-stack
    ../stack/config/: ember-ip-configuration.c
  group udp-cli
    ../app/thread/plugin/udp-cli/: udp-cli.c
  group version-debug
    ../app/thread/plugin/version-debug/: version-debug.c
  group Generated
    ./: thread-bookkeeping.c thread-cli.c thread-events.c thread-callback-stubs.c thread-callbacks.c
  group Additional
    ./: server-implementation.c
    ../hal/micro/cortexm3/: bootloader-interface.c bootloader-interface-app.c
