<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Normal</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>adc</name>
    <file>
      <name>$PROJ_DIR$\..\..\hal\micro\cortexm3\adc.c</name>
    </file>
  </group>
  <group>
    <name>Additional</name>
    <file>
      <name>$PROJ_DIR$\..\..\hal\micro\cortexm3\bootloader-interface-app.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\hal\micro\cortexm3\bootloader-interface.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\client-implementation.c</name>
    </file>
  </group>
  <group>
    <name>address-configuration-debug</name>
    <file>
      <name>$PROJ_DIR$\..\thread\plugin\address-configuration-debug\address-configuration-debug.c</name>
    </file>
  </group>
  <group>
    <name>button</name>
    <file>
      <name>$PROJ_DIR$\..\..\hal\micro\cortexm3\button.c</name>
    </file>
  </group>
  <group>
    <name>buzzer</name>
    <file>
      <name>$PROJ_DIR$\..\..\hal\micro\cortexm3\buzzer.c</name>
    </file>
  </group>
  <group>
    <name>cli</name>
    <file>
      <name>$PROJ_DIR$\..\thread\plugin\cli\cli.c</name>
    </file>
  </group>
  <group>
    <name>coap-cli</name>
    <file>
      <name>$PROJ_DIR$\..\thread\plugin\coap-cli\coap-cli.c</name>
    </file>
  </group>
  <group>
    <name>command-interpreter2</name>
    <file>
      <name>$PROJ_DIR$\..\util\serial\command-interpreter2-error.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\util\serial\command-interpreter2-util.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\util\serial\command-interpreter2.c</name>
    </file>
  </group>
  <group>
    <name>debug-print</name>
    <file>
      <name>$PROJ_DIR$\..\thread\plugin\debug-print\debug-print.c</name>
    </file>
  </group>
  <group>
    <name>dhcp-client</name>
    <file>
      <name>$PROJ_DIR$\..\thread\plugin\dhcp-client\dhcp-client.c</name>
    </file>
  </group>
  <group>
    <name>diagnostic</name>
    <file>
      <name>$PROJ_DIR$\..\..\hal\micro\cortexm3\diagnostic.c</name>
    </file>
  </group>
  <group>
    <name>Generated</name>
    <file>
      <name>$PROJ_DIR$\thread-bookkeeping.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\thread-callback-stubs.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\thread-callbacks.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\thread-cli.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\thread-events.c</name>
    </file>
  </group>
  <group>
    <name>global-address-prefix-debug</name>
    <file>
      <name>$PROJ_DIR$\..\thread\plugin\global-address-prefix-debug\global-address-prefix-debug.c</name>
    </file>
  </group>
  <group>
    <name>hal-library</name>
    <file>
      <name>$PROJ_DIR$\..\..\hal\micro\cortexm3\assert-crash-handlers.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\hal\micro\cortexm3\usb\cdc\callbacks.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\hal\micro\generic\crc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\hal\micro\cortexm3\cstartup-common.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\hal\micro\cortexm3\usb\em_usbd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\hal\micro\cortexm3\usb\em_usbdch9.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\hal\micro\cortexm3\usb\em_usbdep.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\hal\micro\cortexm3\usb\em_usbhal.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\hal\micro\cortexm3\usb\em_usbint.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\hal\micro\cortexm3\usb\em_usbtimer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\hal\micro\generic\endian.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\hal\micro\cortexm3\faults.s79</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\hal\micro\cortexm3\isr-stubs.s79</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\hal\micro\generic\mem-util.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\hal\micro\cortexm3\mfg-token.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\hal\micro\cortexm3\micro-common.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\hal\micro\cortexm3\micro.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\hal\micro\cortexm3\mpu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\hal\micro\generic\random.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\hal\micro\cortexm3\sleep.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\hal\micro\cortexm3\token-def.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\hal\micro\cortexm3\token.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\hal\micro\cortexm3\uart.c</name>
    </file>
  </group>
  <group>
    <name>heartbeat</name>
    <file>
      <name>$PROJ_DIR$\..\thread\plugin\heartbeat\heartbeat.c</name>
    </file>
  </group>
  <group>
    <name>icmp-cli</name>
    <file>
      <name>$PROJ_DIR$\..\thread\plugin\icmp-cli\icmp-cli.c</name>
    </file>
  </group>
  <group>
    <name>icmp-debug</name>
    <file>
      <name>$PROJ_DIR$\..\thread\plugin\icmp-debug\icmp-debug.c</name>
    </file>
  </group>
  <group>
    <name>idle-sleep</name>
    <file>
      <name>$PROJ_DIR$\..\thread\plugin\idle-sleep\idle-sleep.c</name>
    </file>
  </group>
  <group>
    <name>led</name>
    <file>
      <name>$PROJ_DIR$\..\..\hal\micro\cortexm3\led.c</name>
    </file>
  </group>
  <group>
    <name>main</name>
    <file>
      <name>$PROJ_DIR$\..\thread\plugin\main\main.c</name>
    </file>
  </group>
  <group>
    <name>mfglib-library</name>
  </group>
  <group>
    <name>network-management-cli</name>
    <file>
      <name>$PROJ_DIR$\..\thread\plugin\network-management-cli\network-management-cli.c</name>
    </file>
  </group>
  <group>
    <name>scan-debug</name>
    <file>
      <name>$PROJ_DIR$\..\thread\plugin\scan-debug\scan-debug.c</name>
    </file>
  </group>
  <group>
    <name>serial</name>
    <file>
      <name>$PROJ_DIR$\..\util\serial\serial-printf.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\util\serial\serial.c</name>
    </file>
  </group>
  <group>
    <name>sim-eeprom1</name>
    <file>
      <name>$PROJ_DIR$\..\..\hal\micro\generic\sim-eeprom.c</name>
    </file>
  </group>
  <group>
    <name>slaac-client</name>
    <file>
      <name>$PROJ_DIR$\..\thread\plugin\slaac-client\slaac-client.c</name>
    </file>
  </group>
  <group>
    <name>tftp-bootload-target</name>
    <file>
      <name>$PROJ_DIR$\..\util\bootload\tftp\tftp-15-4.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\thread\plugin\tftp-bootload-target\tftp-bootload.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\util\bootload\tftp-bootloader\tftp-bootloader-15-4.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\util\bootload\tftp-bootloader\server\tftp-bootloader-server.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\util\bootload\tftp-bootloader\tftp-bootloader.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\util\bootload\tftp\server\tftp-server.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\util\bootload\tftp\tftp.c</name>
    </file>
  </group>
  <group>
    <name>thread-stack</name>
    <file>
      <name>$PROJ_DIR$\..\..\stack\config\ember-ip-configuration.c</name>
    </file>
  </group>
  <group>
    <name>udp-cli</name>
    <file>
      <name>$PROJ_DIR$\..\thread\plugin\udp-cli\udp-cli.c</name>
    </file>
  </group>
  <group>
    <name>version-debug</name>
    <file>
      <name>$PROJ_DIR$\..\thread\plugin\version-debug\version-debug.c</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\..\..\build\hal-library-cortexm3-iar-em3588-em3xx\hal-library.a</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\build\mfglib-library-cortexm3-iar-em3588-em3xx\mfglib-library.a</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\build\sim-eeprom1-library-cortexm3-iar-em3588-em3xx\sim-eeprom1-library.a</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\build\thread-stack-cortexm3-iar-em3588-em3xx\thread-stack.a</name>
  </file>
</project>


