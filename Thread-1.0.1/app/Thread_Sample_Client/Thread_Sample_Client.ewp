# IAR project Thread_Sample_Client.ewp, settings and files
configuration Normal (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: APP_BTL; CORTEXM3; CORTEXM3_EMBER_MICRO; CORTEXM3_EM3588; PHY_EM3XX; BOARD_HEADER="thread-board.h"; CONFIGURATION_HEADER="thread-configuration.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; __SOURCEFILE__="$FILE_FNAME$"; BOARD_DEV0680ETM; EMBER_AF_API_EMBER_TYPES="stack/include/ember-types.h"; EMBER_STACK_IP; EMBER_RIP_STACK; HAVE_TLS_JPAKE; DEBUG_LEVEL=FULL_DEBUG; APPLICATION_TOKEN_HEADER="thread-token.h"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros; --separate_cluster_for_initialized_variables
  ICCARM.CCIncludePath2: $FILE_DIR$; $PROJ_DIR$; ..\..; ..\..\app\util; ..\..\stack; ..\..\hal; ..\..\hal\..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: APP_BTL; CORTEXM3; CORTEXM3_EMBER_MICRO; CORTEXM3_EM3588; PHY_EM3XX; BOARD_HEADER="thread-board.h"; CONFIGURATION_HEADER="thread-configuration.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; BOARD_DEV0680ETM; EMBER_AF_API_EMBER_TYPES="stack/include/ember-types.h"; EMBER_STACK_IP; EMBER_RIP_STACK; HAVE_TLS_JPAKE; DEBUG_LEVEL=FULL_DEBUG; APPLICATION_TOKEN_HEADER="thread-token.h"
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: Thread_Sample_Client.s37
  prebuild: Thread_Sample_Client-prebuild.bat $PROJ_DIR$
  postbuild: Thread_Sample_Client-postbuild.bat $TARGET_BPATH$
  ILINK.IlinkOutputFile: Thread_Sample_Client.out
  ILINK.IlinkConfigDefines: APP_BTL=1
  ILINK.IlinkIcfFile: ..\..\hal\micro\cortexm3\em35x\em3588\iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: halEntryPoint
  group (top)
    ../../build/hal-library-cortexm3-iar-em3588-em3xx/: hal-library.a
    ../../build/mfglib-library-cortexm3-iar-em3588-em3xx/: mfglib-library.a
    ../../build/sim-eeprom1-library-cortexm3-iar-em3588-em3xx/: sim-eeprom1-library.a
    ../../build/thread-stack-cortexm3-iar-em3588-em3xx/: thread-stack.a
  group adc
    ../../hal/micro/cortexm3/: adc.c
  group Additional
    ../../hal/micro/cortexm3/: bootloader-interface-app.c bootloader-interface.c
    ./: client-implementation.c
  group address-configuration-debug
    ../thread/plugin/address-configuration-debug/: address-configuration-debug.c
  group button
    ../../hal/micro/cortexm3/: button.c
  group buzzer
    ../../hal/micro/cortexm3/: buzzer.c
  group cli
    ../thread/plugin/cli/: cli.c
  group coap-cli
    ../thread/plugin/coap-cli/: coap-cli.c
  group command-interpreter2
    ../util/serial/: command-interpreter2-error.c command-interpreter2-util.c command-interpreter2.c
  group debug-print
    ../thread/plugin/debug-print/: debug-print.c
  group dhcp-client
    ../thread/plugin/dhcp-client/: dhcp-client.c
  group diagnostic
    ../../hal/micro/cortexm3/: diagnostic.c
  group Generated
    ./: thread-bookkeeping.c thread-callback-stubs.c thread-callbacks.c thread-cli.c thread-events.c
  group global-address-prefix-debug
    ../thread/plugin/global-address-prefix-debug/: global-address-prefix-debug.c
  group hal-library
    ../../hal/micro/cortexm3/: assert-crash-handlers.c cstartup-common.c faults.s79 isr-stubs.s79 mfg-token.c micro-common.c micro.c mpu.c sleep.c token-def.c token.c uart.c
    ../../hal/micro/cortexm3/usb/cdc/: callbacks.c
    ../../hal/micro/generic/: crc.c endian.c mem-util.c random.c
    ../../hal/micro/cortexm3/usb/: em_usbd.c em_usbdch9.c em_usbdep.c em_usbhal.c em_usbint.c em_usbtimer.c
  group heartbeat
    ../thread/plugin/heartbeat/: heartbeat.c
  group icmp-cli
    ../thread/plugin/icmp-cli/: icmp-cli.c
  group icmp-debug
    ../thread/plugin/icmp-debug/: icmp-debug.c
  group idle-sleep
    ../thread/plugin/idle-sleep/: idle-sleep.c
  group led
    ../../hal/micro/cortexm3/: led.c
  group main
    ../thread/plugin/main/: main.c
  group network-management-cli
    ../thread/plugin/network-management-cli/: network-management-cli.c
  group scan-debug
    ../thread/plugin/scan-debug/: scan-debug.c
  group serial
    ../util/serial/: serial-printf.c serial.c
  group sim-eeprom1
    ../../hal/micro/generic/: sim-eeprom.c
  group slaac-client
    ../thread/plugin/slaac-client/: slaac-client.c
  group tftp-bootload-target
    ../util/bootload/tftp/: tftp-15-4.c tftp.c
    ../thread/plugin/tftp-bootload-target/: tftp-bootload.c
    ../util/bootload/tftp-bootloader/: tftp-bootloader-15-4.c tftp-bootloader.c
    ../util/bootload/tftp-bootloader/server/: tftp-bootloader-server.c
    ../util/bootload/tftp/server/: tftp-server.c
  group thread-stack
    ../../stack/config/: ember-ip-configuration.c
  group udp-cli
    ../thread/plugin/udp-cli/: udp-cli.c
  group version-debug
    ../thread/plugin/version-debug/: version-debug.c
