# IAR project secure-app-bootloader-local-storage.ewp, settings and files
configuration Normal (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: BOARD_HEADER="hal/micro/cortexm3/em35x/board/dev0682.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar-boot.h"; EMBER_STACK_IP; HAL_MICRO; CORTEXM3; CORTEXM3_EM3596; PHY_NULL; BOARD_DEV0682; CORTEXM3_EMBER_MICRO; BTL_HAS_SERIAL; BOOTLOADER; BOOTLOADER_TYPE=BL_EXT_TYPE_APP_LOCAL_STORAGE; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros; --separate_cluster_for_initialized_variables
  ICCARM.CCIncludePath2: $FILE_DIR$\; ..\..\..\; ..\..\..\STACK\; ..\..\..\HAL\; ..\..\..\; ../../../app/util; ../../../lwip/; ../../../lwip/src/include/; ../../../lwip/contrib/port/FreeRTOS/EM358X/; ../../../lwip/src/include/ipv4/; ../../../lwip/src/include/ipv6/
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: BOARD_HEADER="hal/micro/cortexm3/em35x/board/dev0682.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar-boot.h"; EMBER_STACK_IP; HAL_MICRO; CORTEXM3; CORTEXM3_EM3596; PHY_NULL; BOARD_DEV0682; CORTEXM3_EMBER_MICRO; BTL_HAS_SERIAL; BOOTLOADER; BOOTLOADER_TYPE=BL_EXT_TYPE_APP_LOCAL_STORAGE
  AARM.AUserIncludes: $FILE_DIR$\; ..\..\..\; ..\..\..\STACK\; ..\..\..\HAL\; ..\..\..\; ..\..\..\rtos\FreeRTOS\; ..\..\..\rtos\FreeRTOS\Source\; ..\..\..\rtos\FreeRTOS\Source\include; ..\..\..\rtos\FreeRTOS\Source\portable\IAR\ARM_CM3
  OBJCOPY.OOCOutputFile: secure-app-bootloader-local-storage.s37
  postbuild: "$_ISA3_UTILS_DIR_$\em3xx_convert.exe" "$TARGET_BPATH$.s37" "$TARGET_BPATH$.ebl"
  ILINK.IlinkOutputFile: secure-app-bootloader-local-storage.out
  ILINK.IlinkConfigDefines: BOOTLOADER=1
  ILINK.IlinkIcfFile: ../../../hal/micro/cortexm3/em35x/em3596/iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: halEntryPoint
  group (top)
    ../../../hal/micro/cortexm3/bootloader/: app-bootloader-custom.c bootloader-gpio.c bootloader-uart.c cstartup-iar-boot-entry.s79 cstartup-iar-boot.c em35x-internal-flash.c
    ../../../hal/micro/generic/: crc.c mem-util.c random.c
    ../../../hal/micro/cortexm3/: isr-stubs.s79 led.c mfg-token.c micro-common.c
    ../../../build/secure-app-bootloader-library-cortexm3-iarboot-em3596-null/: secure-app-bootloader-library.a
